# Autodesk Inventor part: 100CYL-35mm
## iProperties
Created: 2011-01
Part Number: 100CYL-35mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
